IMAGE_INSTALL:append = " lighttpd nylon-web"
